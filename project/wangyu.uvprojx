# Keil uVision project wangyu.uvprojx, settings and files
target wangyu (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wangyu +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER;..\BSP\LEd;..\BSP\BEEP;..\BSP\SysTick;..\BSP\Infrared;..\BSP\MQ_2;..\BSP\ADC;..\BSP\EXTI;..\BSP\SR04;..\BSP\TIM;..\BSP\USART;..\BSP\ST_string;..\BSP\GPRS;..\BSP\key;..\BSP\key\Key;..\BSP\Run_task;..\BSP\Data_Structure;..\BSP\Data_Structure\SeqQueue;..\BSP\RFID;..\BSP\SPI;..\BSP\I2C;..\BSP\SPI;..\BSP\eeprom;..\BSP\key\buttom;..\BSP\RFID_SPI;..\BSP\Data_Structure\SeqQueue;..\BSP\Raster_ruler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Doc
    ../doc/: Readme.txt
  group lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group BSP
    ../BSP/LEd/: led_driver.c
    ../BSP/SysTick/: SysTick.c
    ../BSP/BEEP/: beep_driver.c
    ../BSP/MQ_2/: smoke_driver.c
    ../BSP/I2C/: i2c_driver.c
    ../BSP/SR04/: hc_sr04.c
    ../BSP/Infrared/: infrared.c
    ../BSP/TIM/: tim_driver.c timer.c
    ../BSP/EXTI/: exti_driver.c
    ../BSP/USART/: usart_driver.c
    ../BSP/ST_string/: ST_string.c
    ../BSP/GPRS/: gprs_driver.c
    ../BSP/SPI/: spi.c
    ../BSP/key/: key_driver.c
    ../BSP/Run_task/: Run_task.c
    ../BSP/Data_Structure/SeqQueue/: SeqList.c SeqQueue.c
    ../BSP/Data_Structure/: Data_Structure.c
    ../BSP/Raster_ruler/: raster_ruler.c
  group User
    ../USER/: main.c stm32f10x_it.c
